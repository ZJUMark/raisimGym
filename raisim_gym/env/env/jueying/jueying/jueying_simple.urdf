Commit message: try 2 fail

File: raisim_gym/env/env/jueying/jueying/jueying_simple.urdf (robot description, URDF)
Before this commit: robot jueying, 14 links, 13 joints
Links:
- link base_link: geometry collision box size=0.76 0.18 0.18; collision sphere radius=0.09
